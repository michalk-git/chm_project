# IAR project dpp-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm-cm\qk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\ek-tm4c123gxl
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qk.bin
  ILINK.IlinkOutputFile: dpp-qk.out
  ILINK.IlinkIcfFile: dpp-qk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: bsp.c
    ../../: bsp.h dpp.h main.c philo.c table.c
  group ek-tm4c123gxl
    ../../../../../3rd_party/ek-tm4c123gxl/iar/: startup_TM4C123GH6PM.s
    ../../../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c system_TM4C123GH6PM.h TM4C123GH6PM.h
  group QP
    ../../../../../src/qfn/: qepn.c qfn.c
    ../../../../../src/qkn/: qkn.c
  group QP_port
    ../../../../../ports/arm-cm/qk/iar/: qfn_port.h qkn_port.c
