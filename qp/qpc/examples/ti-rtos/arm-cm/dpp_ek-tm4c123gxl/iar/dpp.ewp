# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; --diag_suppress=Pa050; -I$TIVAWARE$; -I$BIOS$/ti/sysbios/posix; -DPART_TM4C123GH6PM; -Dewarm; -DTIVAWARE; --debug; --silent
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\ti-rtos
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $TIVAWARE$/grlib/ewarm/Exe/grlib.a; $TIVAWARE$/usblib/ewarm/Exe/usblib.a; $TIVAWARE$/driverlib/ewarm/Exe/driverlib.a; --silent; --cpu=Cortex-M4F; --entry=__iar_program_start; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: $PROJ_FNAME$_EK_TM4C123GXL.icf
  group Application
    ./: Board.h dpp.cfg dpp_EK_TM4C123GXL.icf EK_TM4C123GXL.h
    ../: Board.h bsp.c bsp.h dpp.h EK_TM4C123GXL.c EK_TM4C123GXL.h main.c philo.c table.c
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h
  group QP_port
    ../../../../../ports/ti-rtos/: qep_port.h qf_port.c qf_port.h qs_port.h
